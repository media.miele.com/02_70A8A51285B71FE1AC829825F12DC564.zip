Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 4c51350a-b32f-4e0e-90c5-882738665d61, NumberOfSaves: 1]
File name: 0001
Time: 2026-09-10T22:54:33+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12509550_NER_KMDA7676FL-U:26767679_NER_12509550_KMDA7676FL-U, (2)
In: Default
Type - Material: z_Miele_Design_CLST, z_Miele_Design_print, z_Miele_Design_OBSW, <Unnamed>, z_Miele_Connection_Electric
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 800 mm; Height: 238 mm; Depth: 520 mm
Classification: E1090320 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 26767679_NER_12509550_KMDA7676FL-U; sets with these values: 2
